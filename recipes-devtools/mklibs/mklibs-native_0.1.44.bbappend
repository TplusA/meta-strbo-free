FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Remove-dynamic-exception-specifications-for-C-17.patch"
PR = "r1"
