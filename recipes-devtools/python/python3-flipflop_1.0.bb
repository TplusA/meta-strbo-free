inherit pypi setuptools3
require python-flipflop.inc
