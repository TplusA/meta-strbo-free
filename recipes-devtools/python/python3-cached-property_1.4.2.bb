inherit pypi setuptools3
require python-cached-property.inc
