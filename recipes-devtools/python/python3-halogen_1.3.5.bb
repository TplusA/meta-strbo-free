inherit pypi setuptools3
require python-halogen.inc
