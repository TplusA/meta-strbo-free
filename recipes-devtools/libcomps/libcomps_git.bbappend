FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Remove-unused-global-variable-UnfoObjListIt-RhBug-17.patch"
PR = "r1"
