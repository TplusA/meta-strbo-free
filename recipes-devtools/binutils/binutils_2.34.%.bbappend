EXTRA_OEMAKE = "'CFLAGS=-fcommon'"
