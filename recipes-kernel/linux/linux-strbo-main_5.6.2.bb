STRBO_KERNEL_PR = "r1+main"

require linux-strbo_5.6.2.inc
require linux-strbo-main.inc
require linux-strbo.inc
