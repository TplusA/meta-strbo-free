STRBO_KERNEL_PR = "r4+recovery"

require linux-strbo_5.10.25.inc
require linux-strbo-recovery.inc
require linux-strbo.inc
