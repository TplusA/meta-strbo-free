STRBO_KERNEL_PR = "r0+recovery"

require linux-strbo_5.10.95.inc
require linux-strbo-recovery.inc
require linux-strbo.inc
