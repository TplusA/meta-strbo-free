STRBO_KERNEL_PR = "r2+main"

require linux-strbo_4.19.60.inc
require linux-strbo-main.inc
require linux-strbo.inc
