STRBO_KERNEL_PR = "r1+recovery"

require linux-strbo_4.19.60.inc
require linux-strbo-recovery.inc
require linux-strbo.inc
