STRBO_KERNEL_PR = "r1+main"

require linux-strbo_5.10.17.inc
require linux-strbo-main.inc
require linux-strbo.inc
