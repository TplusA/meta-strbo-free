STRBO_KERNEL_PR = "r2+recovery"

require linux-strbo_5.6.2.inc
require linux-strbo-recovery.inc
require linux-strbo.inc
