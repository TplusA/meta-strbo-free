STRBO_KERNEL_PR = "r1+recovery"

require linux-strbo_5.6.19.inc
require linux-strbo-recovery.inc
require linux-strbo.inc
