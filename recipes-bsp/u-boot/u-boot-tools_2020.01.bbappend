FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0006-Remove-redundant-YYLOC-global-declaration.patch"
PR = "r1"
