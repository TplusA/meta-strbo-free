FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://avoid_the_doctemplates_hack.patch"
