FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"
SRC_URI += "file://0001-discovery-request-Remove-warning-about-requests-with.patch"
PR = "r1"
