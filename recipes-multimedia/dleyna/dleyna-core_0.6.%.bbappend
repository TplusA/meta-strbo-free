FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Fix-crash-while-cancelling-all-task-queues.patch"
PR = "r1"
