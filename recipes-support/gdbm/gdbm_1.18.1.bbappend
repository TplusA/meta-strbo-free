FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-parseopt-Fix-compilation-with-gcc-10.patch"
PR = "r1"
