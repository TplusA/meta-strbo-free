FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-migrate-from-custom-itstool-to-builtin-msgfmt-for-cr.patch"
