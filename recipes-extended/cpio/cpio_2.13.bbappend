EXTRA_OEMAKE = "'CFLAGS=-fcommon'"
PR = "r1"
