FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-groff-Do-not-use-sys_siglist.patch"
PR = "r1"
